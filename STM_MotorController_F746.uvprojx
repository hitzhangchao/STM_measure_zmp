# Keil uVision project STM_MotorController_F746.uvprojx, settings and files
target STM_MotorController_F746 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746ZG STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: CPUTYPE("Cortex-M7") FPU2
  output: STM_MotorController_F746
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DTARGET_STM32F746 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD -DDEVICE_RTC=1 --split_sections -DFEATURE_LWIP=1 -DTARGET_STM32F7 -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -DDEVICE_PORTINOUT=1 -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DTARGET_RTOS_M4_M7 -DDEVICE_CAN=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED -DARM_MATH_CM7 -DDEVICE_SPI_ASYNCH=1 -DTARGET_LIKE_CORTEX_M7 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M --cpu=Cortex-M7.fp.sp -DDEVICE_I2C=1 --preinclude=mbed_config.h -DDEVICE_LOWPOWERTIMER=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 -DDEVICE_ANALOGIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED -D__CMSIS_RTOS --md -DMBED_BUILD_TIMESTAMP=1494382541.25 -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu -DTARGET_STM32F746xG -DDEVICE_TRNG=1 --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_NUCLEO_F746ZG -DDEVICE_SPISLAVE=1 -D__CORTEX_M7 -DTARGET_M7 -DDEVICE_SERIAL=1 -D__FPU_PRESENT=1 -DDEVICE_I2CSLAVE=1 -DUSBHOST_OTHER -DTARGET_STM32F746ZG -DTRANSACTION_QUEUE_SIZE_SPI=2 -D__MBED_CMSIS_RTOS_CM
  c include: .; mbed-dev; mbed-dev/cmsis; mbed-dev/drivers; mbed-dev/hal; mbed-dev/hal/storage_abstraction; mbed-dev/platform; mbed-dev/targets; mbed-dev/targets/TARGET_STM; mbed-dev/targets/TARGET_STM/TARGET_STM32F7; mbed-dev/targets/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG; mbed-dev/targets/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/TARGET_NUCLEO_F746ZG; mbed-dev/targets/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/device; mbed-dev/targets/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/device/TOOLCHAIN_ARM_STD; mbed-dev/targets/TARGET_STM/TARGET_STM32F7/device
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DTRANSACTION_QUEUE_SIZE_SPI=2,-D__CORTEX_M7,-DARM_MATH_CM7,-D__FPU_PRESENT=1,-DUSBHOST_OTHER,-D__MBED_CMSIS_RTOS_CM,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed-dev/targets/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/device/TOOLCHAIN_ARM_STD/stm32f746xg.sct
  group mbed-dev
    mbed-dev/drivers/: AnalogIn.cpp AnalogIn.h AnalogOut.h BusIn.cpp BusIn.h BusInOut.cpp BusInOut.h BusOut.cpp BusOut.h CAN.cpp CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.cpp Ethernet.h FileBase.cpp FileBase.h FileHandle.h FileLike.cpp FileLike.h FilePath.cpp FilePath.h FileSystemLike.cpp FileSystemLike.h I2C.cpp I2C.h I2CSlave.cpp I2CSlave.h InterruptIn.cpp InterruptIn.h InterruptManager.cpp InterruptManager.h LocalFileSystem.cpp LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.cpp RawSerial.h Serial.cpp Serial.h SerialBase.cpp SerialBase.h SPI.cpp SPI.h SPISlave.cpp SPISlave.h Stream.cpp Stream.h Ticker.cpp Ticker.h Timeout.cpp Timeout.h Timer.cpp Timer.h TimerEvent.cpp TimerEvent.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F7/: analogin_api.c analogout_api.c can_api.c common_objects.h device.h gpio_irq_api.c i2c_device.h mbed_overrides.c pinmap.c port_api.c pwmout_api.c serial_api.c spi_api.c
    mbed-dev/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h emac_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h mbed_gpio.c mbed_lp_ticker_api.c mbed_pinmap_common.c mbed_ticker_api.c mbed_us_ticker_api.c pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed-dev/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed-dev/platform/: Callback.h CallChain.cpp CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_alloc_wrappers.cpp mbed_assert.c mbed_assert.h mbed_board.c mbed_critical.c mbed_debug.h mbed_error.c mbed_error.h mbed_interface.c mbed_interface.h mbed_mem_trace.c mbed_mem_trace.h mbed_preprocessor.h mbed_rtc_time.cpp mbed_semihost_api.c mbed_stats.c mbed_stats.h mbed_wait_api_no_rtos.c mbed_wait_api_rtos.cpp platform.h PlatformMutex.h retarget.cpp rtc_time.h semihost_api.h SingletonPtr.h toolchain.h Transaction.h wait_api.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/device/: cmsis.h cmsis_nvic.c cmsis_nvic.h hal_tick.h stm32f746xx.h stm32f7xx.h system_stm32f7xx.h
    mbed-dev/hal/storage_abstraction/: Driver_Common.h Driver_Storage.h
    mbed-dev/targets/TARGET_STM/: gpio_api.c gpio_object.h hal_tick_16b.c hal_tick_32b.c i2c_api.c lp_ticker.c mbed_rtx.h PeripheralPins.h PinNamesTypes.h PortNames.h rtc_api.c rtc_api_hal.h sleep.c stm_spi_api.c trng_api.c us_ticker_16b.c us_ticker_32b.c
    mbed-dev/: mbed.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/: objects.h
    mbed-dev/targets/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/TARGET_NUCLEO_F746ZG/: PeripheralNames.h PeripheralPins.c PinNames.h system_stm32f7xx.c
    mbed-dev/targets/TARGET_STM/TARGET_STM32F7/TARGET_STM32F746xG/device/TOOLCHAIN_ARM_STD/: startup_stm32f746xg.S sys.cpp
    mbed-dev/targets/TARGET_STM/TARGET_STM32F7/device/: stm32_hal_legacy.h stm32f7xx_hal.c stm32f7xx_hal.h stm32f7xx_hal_adc.c stm32f7xx_hal_adc.h stm32f7xx_hal_adc_ex.c stm32f7xx_hal_adc_ex.h stm32f7xx_hal_can.c stm32f7xx_hal_can.h stm32f7xx_hal_cec.c stm32f7xx_hal_cec.h stm32f7xx_hal_conf.h stm32f7xx_hal_cortex.c stm32f7xx_hal_cortex.h stm32f7xx_hal_crc.c stm32f7xx_hal_crc.h stm32f7xx_hal_crc_ex.c stm32f7xx_hal_crc_ex.h stm32f7xx_hal_cryp.c stm32f7xx_hal_cryp.h stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_cryp_ex.h stm32f7xx_hal_dac.c stm32f7xx_hal_dac.h stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dac_ex.h stm32f7xx_hal_dcmi.c stm32f7xx_hal_dcmi.h stm32f7xx_hal_dcmi_ex.c stm32f7xx_hal_dcmi_ex.h stm32f7xx_hal_def.h stm32f7xx_hal_dfsdm.c stm32f7xx_hal_dfsdm.h stm32f7xx_hal_dma.c stm32f7xx_hal_dma.h stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma2d.h stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma_ex.h stm32f7xx_hal_dsi.c stm32f7xx_hal_dsi.h stm32f7xx_hal_eth.c stm32f7xx_hal_eth.h stm32f7xx_hal_flash.c stm32f7xx_hal_flash.h stm32f7xx_hal_flash_ex.c stm32f7xx_hal_flash_ex.h stm32f7xx_hal_gpio.c stm32f7xx_hal_gpio.h stm32f7xx_hal_gpio_ex.h stm32f7xx_hal_hash.c stm32f7xx_hal_hash.h stm32f7xx_hal_hash_ex.c stm32f7xx_hal_hash_ex.h stm32f7xx_hal_hcd.c stm32f7xx_hal_hcd.h stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c.h stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_i2c_ex.h stm32f7xx_hal_i2s.c stm32f7xx_hal_i2s.h stm32f7xx_hal_irda.c stm32f7xx_hal_irda.h stm32f7xx_hal_irda_ex.h stm32f7xx_hal_iwdg.c stm32f7xx_hal_iwdg.h stm32f7xx_hal_jpeg.c stm32f7xx_hal_jpeg.h stm32f7xx_hal_lptim.c stm32f7xx_hal_lptim.h stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc.h stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_ltdc_ex.h stm32f7xx_hal_mdios.c stm32f7xx_hal_mdios.h stm32f7xx_hal_nand.c stm32f7xx_hal_nand.h stm32f7xx_hal_nor.c stm32f7xx_hal_nor.h stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd.h stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pcd_ex.h stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr.h stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_pwr_ex.h stm32f7xx_hal_qspi.c stm32f7xx_hal_qspi.h stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc.h stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rcc_ex.h stm32f7xx_hal_rng.c stm32f7xx_hal_rng.h stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc.h stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_rtc_ex.h stm32f7xx_hal_sai.c stm32f7xx_hal_sai.h stm32f7xx_hal_sai_ex.c stm32f7xx_hal_sai_ex.h stm32f7xx_hal_sd.c stm32f7xx_hal_sd.h stm32f7xx_hal_sdram.c stm32f7xx_hal_sdram.h stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard.h stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_smartcard_ex.h stm32f7xx_hal_spdifrx.c stm32f7xx_hal_spdifrx.h stm32f7xx_hal_spi.c stm32f7xx_hal_spi.h stm32f7xx_hal_sram.c stm32f7xx_hal_sram.h stm32f7xx_hal_tim.c stm32f7xx_hal_tim.h stm32f7xx_hal_tim_ex.c stm32f7xx_hal_tim_ex.h stm32f7xx_hal_uart.c stm32f7xx_hal_uart.h stm32f7xx_hal_uart_ex.h stm32f7xx_hal_usart.c stm32f7xx_hal_usart.h stm32f7xx_hal_usart_ex.h stm32f7xx_hal_wwdg.c stm32f7xx_hal_wwdg.h stm32f7xx_ll_fmc.c stm32f7xx_ll_fmc.h stm32f7xx_ll_sdmmc.c stm32f7xx_ll_sdmmc.h stm32f7xx_ll_usb.c stm32f7xx_ll_usb.h
  group STM_MotorController_F746
    ./: AS5600.cpp AS5600.h b3m.h Flash.cpp Flash.h main.cpp mbed_config.h Parser.cpp Parser.h RS485.cpp RS485.h STM_BLDCMotor.cpp STM_BLDCMotor.h
